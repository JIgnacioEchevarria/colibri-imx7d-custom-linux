FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://libfm_set_terminal.patch"
