require mediainfo_22.06.inc

S = "${WORKDIR}/MediaInfo_CLI_GNU_FromSource/ZenLib/Project/GNU/Library"
