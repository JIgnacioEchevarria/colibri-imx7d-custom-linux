require mediainfo_22.06.inc

DEPENDS:append = " zenlib"

S = "${WORKDIR}/MediaInfo_CLI_GNU_FromSource/MediaInfoLib/Project/GNU/Library"
