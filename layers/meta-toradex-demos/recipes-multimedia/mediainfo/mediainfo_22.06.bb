require mediainfo_22.06.inc

DEPENDS:append = " mediainfolib"

S = "${WORKDIR}/MediaInfo_CLI_GNU_FromSource/MediaInfo/Project/GNU/CLI"
