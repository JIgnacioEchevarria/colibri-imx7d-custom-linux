RDEPENDS:${PN} += "nativesdk-python3-json"
