FILESEXTRAPATHS:prepend := "${THISDIR}/busybox:"

SRC_URI += "file://resize.cfg"
