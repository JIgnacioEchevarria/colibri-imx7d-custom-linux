FILESEXTRAPATHS:prepend:tdx-distro := "${THISDIR}/systemd-conf:"
