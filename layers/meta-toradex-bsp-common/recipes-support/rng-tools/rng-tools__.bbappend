PACKAGECONFIG:remove:tdx-distro = "libjitterentropy"
