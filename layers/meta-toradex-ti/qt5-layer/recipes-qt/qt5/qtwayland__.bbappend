PACKAGECONFIG:remove:k3 = "wayland-vulkan-server-buffer xcomposite-egl xcomposite-glx"
PACKAGE_ARCH:k3 = "${MACHINE_ARCH}"
