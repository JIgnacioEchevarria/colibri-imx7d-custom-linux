PACKAGE_ARCH:k3 = "${MACHINE_ARCH}"
