PACKAGECONFIG:remove:k3 = "glamor glx"
PACKAGE_ARCH:k3 = "${MACHINE_ARCH}"
