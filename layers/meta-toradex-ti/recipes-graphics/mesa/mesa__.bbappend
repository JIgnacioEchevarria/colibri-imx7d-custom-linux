# Enable Imagination PowerVR support
PACKAGECONFIG:append:upstream:k3 = " imagination"
